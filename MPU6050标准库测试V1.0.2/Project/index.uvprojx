# Keil uVision project index.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: index +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Core;..\Stdlib\inc;..\Bsp;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Module
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c
  group Bsp
    ../Bsp/: Bsp_IIC1_Init.c Bsp_MPU6050_Init.c led.c
  group Core
    ../Core/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group Stdlib
    ../Stdlib/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group Module
    ../Module/: inv_mpu.c inv_mpu_dmp_motion_driver.c
